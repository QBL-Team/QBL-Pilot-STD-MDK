# Keil uVision project Project.uvprojx, settings and files
target QBL-Pilot-STD (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: QBL-Pilot-STD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE=8000000,PLL_M=8,USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c misc: --C99
  c include: ..\;..\..\..\Libraries\STD\CMSIS\Include;..\..\..\Libraries\STD\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STD\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\FatFS;..\Module\Hardware;..\Module\Driver;..\Module\Tools;..\Module\BSP;..\User;..\Example
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group User
    ../User/: main.c Tasks.c SystemParams.c stm32f4xx_it.c
  group BSP
    ../Module/BSP/: eskfAHRS.c SensorDataCollect.c SensorParam.c SDcardWriteAndRead.c KalmanFilter.c BasicMath.c
  group Tools
    ../Module/Tools/: SensorDataCollectForCali.c
  group Middleware/FatFS
    ../../../Libraries/FatFS/: diskio.c ff.c
    ../../../Libraries/FatFS/option/: cc936.c
  group Driver
    ../Module/Driver/: Driver.c DispatchClock.c Basic_Type.c LED.c MPU6050.c HMC5883.c MS5611.c W25QXX.c PWMInput.c PWMOutput.c SDcard.c
  group Hardware
    ../Module/Hardware/: QBL.c QBL_Key.c QBL_SD.c QBL_I2C.c QBL_SPI.c QBL_USART1.c QBL_Type.c QBL_SysTick.c QBL_FPU_BasicMath.c
  group STD
    ../../../Libraries/STD/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../../../Libraries/STD/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../../../Libraries/STD/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../../Libraries/STD/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Example
    ../Example/: test_Allan_variance.c test_acc_calibration.c test_SD.c test_W25QXX.c test_MS5611.c test_HMC5883.c test_MPU6050.c test_USART1.c test_LED.c
  group Doc
    ./: readme.txt
